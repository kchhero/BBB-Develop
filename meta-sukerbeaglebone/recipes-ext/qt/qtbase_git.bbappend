PACKAGECONFIG:append = " accessibility eglfs fontconfig linuxfb tslib"
